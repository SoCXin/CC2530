# IAR project App.ewp, settings and files
configuration QITAS (8051, debug)
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: ZIGBEEPRO; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\ZMAIN\TI2530DB; ..\..\COMPONENTS\MT; ..\..\COMPONENTS\HAL\INCLUDE; ..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\COMPONENTS\OSAL\INCLUDE; ..\..\COMPONENTS\STACK\AF; ..\..\COMPONENTS\STACK\NWK; ..\..\COMPONENTS\STACK\SEC; ..\..\COMPONENTS\STACK\SAPI; ..\..\COMPONENTS\STACK\SYS; ..\..\COMPONENTS\STACK\ZDO; ..\..\COMPONENTS\ZMAC\F8W; ..\..\COMPONENTS\ZMAC; ..\..\COMPONENTS\SERVICES\SADDR; ..\..\COMPONENTS\SERVICES\SDATA; ..\..\COMPONENTS\MAC\INCLUDE; ..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\ZMAIN\TI2530DB; ..\..\COMPONENTS\MT; ..\..\COMPONENTS\HAL\INCLUDE; ..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\COMPONENTS\OSAL\INCLUDE; ..\..\COMPONENTS\STACK\AF; ..\..\COMPONENTS\STACK\NWK; ..\..\COMPONENTS\STACK\SEC; ..\..\COMPONENTS\STACK\SAPI; ..\..\COMPONENTS\STACK\SYS; ..\..\COMPONENTS\STACK\ZDO; ..\..\COMPONENTS\ZMAC\F8W; ..\..\COMPONENTS\ZMAC; ..\..\COMPONENTS\SERVICES\SADDR; ..\..\COMPONENTS\SERVICES\SDATA; ..\..\COMPONENTS\MAC\INCLUDE; ..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\OMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
configuration EndDeviceEB-Pro (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; ZTOOL_P1; xMT_TASK; xMT_SYS_FUNC; xMT_ZDO_FUNC; LCD_SUPPORTED=DEBUG
  group App
    ../Source/: App.c App.h AppHw.c AppHw.h DHT11.c DHT11.h OSAL_APP.c
  group HAL/Common
    ../../components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../components/stack/af/: AF.c AF.h
  group Security
    ../../components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../components/zmac/: ZMAC.h
  group ZMain
    ../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
